<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\es_simples\es_simples.ewp</path>
    </project>
    <batchBuild />
</workspace>
